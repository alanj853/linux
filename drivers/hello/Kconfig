## drivers/hello/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
menuconfig HELLO
	tristate "HELLO support"
	help
	  This is Alan's First HELLO driver
```
